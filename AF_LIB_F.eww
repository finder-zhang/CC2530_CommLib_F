<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AF_LIB_F.ewp</path>
  </project>
  <batchBuild/>
</workspace>


